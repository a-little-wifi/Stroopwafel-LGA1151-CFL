# Repository a-little-wifi/Stroopwafel-LGA1151-CFL (continued)

## KiCad design Stroopwafel-LGA1151-CFL.kicad_pcb (continued)

Schematic: PCH_Highspeed_Clock_LPC_eSPI.kicad_sch, PCH DMI, PCIe, SATA, USB3, USB2, Clockgen, CNVi, LPC/eSPI &…

Parts:
R38: 619Ω; R_0402_1005Metric
R41: 1kΩ; R_0402_1005Metric; not fitted
UPCH1: Intel Cannon Point 300-Series Platform Controller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; CNP-H_BGA_874P-T

Connections:
CPU_24MCLK+: UPCH1.D7 (CLKOUT_CPUNSSC_P); also elsewhere on the board
CPU_24MCLK-: UPCH1.C6 (CLKOUT_CPUNSSC_N); also elsewhere on the board
CPU_BCLK+: UPCH1.B8 (CLKOUT_CPUBCLK_P); also elsewhere on the board
CPU_BCLK-: UPCH1.C8 (CLKOUT_CPUBCLK_N); also elsewhere on the board
CPU_PCIBCLK+: UPCH1.A6 (CLKOUT_CPUPCIBCLK_P); also elsewhere on the board
CPU_PCIBCLK-: UPCH1.B6 (CLKOUT_CPUPCIBCLK_N); also elsewhere on the board
GND: R41.1; also elsewhere on the board
unnamed: R38.1, UPCH1.AD3 (THRMTRIP#)
PCH_x4_1_CLKREQ#: UPCH1.AN29 (GPP_B10/SRCCLKREQ5#); also elsewhere on the board
PCH_x4_1_PCIe_Rx0+: UPCH1.F16 (PCIE1_RXP/USB3.1G1_7_RXP); also elsewhere on the board
PCH_x4_1_PCIe_Rx0-: UPCH1.G17 (PCIE1_RXN/USB3.1G1_7_RXN); also elsewhere on the board
PCH_x4_1_PCIe_Rx1+: UPCH1.P21 (PCIE2_RXP/USB3.1G1_8_RXP); also elsewhere on the board
PCH_x4_1_PCIe_Rx1-: UPCH1.R21 (PCIE2_RXN/USB3.1G1_8_RXN); also elsewhere on the board
PCH_x4_1_PCIe_Rx2+: UPCH1.J18 (PCIE3_RXP/USB3.1G1_9_RXP); also elsewhere on the board
PCH_x4_1_PCIe_Rx2-: UPCH1.K18 (PCIE3_RXN/USB3.1G1_9_RXN); also elsewhere on the board
PCH_x4_1_PCIe_Rx3+: UPCH1.R18 (PCIE4_RXP/USB3.1G1_10_RXP); also elsewhere on the board
PCH_x4_1_PCIe_Rx3-: UPCH1.N18 (PCIE4_RXN/USB3.1G1_10_RXN); also elsewhere on the board
PCH_x4_1_PCIe_Tx0+: UPCH1.B17 (PCIE1_TXP/USB3.1G1_7_TXP); also elsewhere on the board
PCH_x4_1_PCIe_Tx0-: UPCH1.A17 (PCIE1_TXN/USB3.1G1_7_TXN); also elsewhere on the board
PCH_x4_1_PCIe_Tx1+: UPCH1.C18 (PCIE2_TXP/USB3.1G1_8_TXP); also elsewhere on the board
PCH_x4_1_PCIe_Tx1-: UPCH1.B18 (PCIE2_TXN/USB3.1G1_8_TXN); also elsewhere on the board
PCH_x4_1_PCIe_Tx2+: UPCH1.C19 (PCIE3_TXP/USB3.1G1_9_TXP); also elsewhere on the board
PCH_x4_1_PCIe_Tx2-: UPCH1.B19 (PCIE3_TXN/USB3.1G1_9_TXN); also elsewhere on the board
PCH_x4_1_PCIe_Tx3+: UPCH1.C20 (PCIE4_TXP/USB3.1G1_10_TXP); also elsewhere on the board
PCH_x4_1_PCIe_Tx3-: UPCH1.D20 (PCIE4_TXN/USB3.1G1_10_TXN); also elsewhere on the board
PCH_x4_1_Refclk+: UPCH1.AB3 (CLKOUT_PCIE_P5); also elsewhere on the board
PCH_x4_1_Refclk-: UPCH1.AB2 (CLKOUT_PCIE_N5); also elsewhere on the board
PCH_x4_4_CLKREQ#: UPCH1.BA30 (GPP_B9/SRCCLKREQ4#); also elsewhere on the board
PCH_x4_4_PCIe_Rx0+: UPCH1.C38 (PCIE13_TXP/SATA0B_TXP); also elsewhere on the board
PCH_x4_4_PCIe_Rx0-: UPCH1.B38 (PCIE13_TXN/SATA0B_TXN); also elsewhere on the board
PCH_x4_4_PCIe_Rx1+: UPCH1.D39 (PCIE14_TXP/SATA1B_TXP); also elsewhere on the board
PCH_x4_4_PCIe_Rx1-: UPCH1.C39 (PCIE14_TXN/SATA1B_TXN); also elsewhere on the board
PCH_x4_4_PCIe_Rx2+: UPCH1.C40 (PCIE15_TXP/SATA2_TXP); also elsewhere on the board
PCH_x4_4_PCIe_Rx2-: UPCH1.B40 (PCIE15_TXN/SATA2_TXN); also elsewhere on the board
PCH_x4_4_PCIe_Rx3+: UPCH1.C41 (PCIE16_TXP/SATA3_TXP); also elsewhere on the board
PCH_x4_4_PCIe_Rx3-: UPCH1.B41 (PCIE16_TXN/SATA3_TXN); also elsewhere on the board
PCH_x4_4_PCIe_Tx0+: UPCH1.C46 (PCIE13_RXP/SATA0B_RXP); also elsewhere on the board
PCH_x4_4_PCIe_Tx0-: UPCH1.C45 (PCIE13_RXN/SATA0B_RXN); also elsewhere on the board
PCH_x4_4_PCIe_Tx1+: UPCH1.C47 (PCIE14_RXP/SATA1B_RXP); also elsewhere on the board
PCH_x4_4_PCIe_Tx1-: UPCH1.D46 (PCIE14_RXN/SATA1B_RXN); also elsewhere on the board
PCH_x4_4_PCIe_Tx2+: UPCH1.E45 (PCIE15_RXP/SATA2_RXP); also elsewhere on the board
PCH_x4_4_PCIe_Tx2-: UPCH1.F44 (PCIE15_RXN/SATA2_RXN); also elsewhere on the board
PCH_x4_4_PCIe_Tx3+: UPCH1.M40 (PCIE16_RXP/SATA3_RXP); also elsewhere on the board
PCH_x4_4_PCIe_Tx3-: UPCH1.L41 (PCIE16_RXN/SATA3_RXN); also elsewhere on the board
PCH_x4_4_Refclk+: UPCH1.AC3 (CLKOUT_PCIE_P4); also elsewhere on the board
PCH_x4_4_Refclk-: UPCH1.AC2 (CLKOUT_PCIE_N4); also elsewhere on the board
PCH_x4_5_CLKREQ#: UPCH1.BB30 (GPP_B8/SRCCLKREQ3#); also elsewhere on the board
PCH_x4_5_PCIe_Rx0+: UPCH1.K44 (PCIE17_RXP/SATA4_RXP); also elsewhere on the board
PCH_x4_5_PCIe_Rx0-: UPCH1.K43 (PCIE17_RXN/SATA4_RXN); also elsewhere on the board
PCH_x4_5_PCIe_Rx1+: UPCH1.R40 (PCIE18_RXP/SATA5_RXP); also elsewhere on the board
PCH_x4_5_PCIe_Rx1-: UPCH1.P41 (PCIE18_RXN/SATA5_RXN); also elsewhere on the board
PCH_x4_5_PCIe_Rx2+: UPCH1.N42 (PCIE19_RXP/SATA6_RXP); also elsewhere on the board
PCH_x4_5_PCIe_Rx2-: UPCH1.M44 (PCIE19_RXN/SATA6_RXN); also elsewhere on the board
PCH_x4_5_PCIe_Rx3+: UPCH1.R37 (PCIE20_RXP/SATA7_RXP); also elsewhere on the board
PCH_x4_5_PCIe_Rx3-: UPCH1.R35 (PCIE20_RXN/SATA7_RXN); also elsewhere on the board
PCH_x4_5_PCIe_Tx0+: UPCH1.B42 (PCIE17_TXP/SATA4_TXP); also elsewhere on the board
PCH_x4_5_PCIe_Tx0-: UPCH1.A42 (PCIE17_TXN/SATA4_TXN); also elsewhere on the board
PCH_x4_5_PCIe_Tx1+: UPCH1.D42 (PCIE18_TXP/SATA5_TXP); also elsewhere on the board
PCH_x4_5_PCIe_Tx1-: UPCH1.C42 (PCIE18_TXN/SATA5_TXN); also elsewhere on the board
PCH_x4_5_PCIe_Tx2+: UPCH1.D43 (PCIE19_TXP/SATA6_TXP); also elsewhere on the board
PCH_x4_5_PCIe_Tx2-: UPCH1.C44 (PCIE19_TXN/SATA6_TXN); also elsewhere on the board
PCH_x4_5_PCIe_Tx3+: UPCH1.B44 (PCIE20_TXP/SATA7_TXP); also elsewhere on the board
PCH_x4_5_PCIe_Tx3-: UPCH1.A44 (PCIE20_TXN/SATA7_TXN); also elsewhere on the board
PCH_x4_5_Refclk+: UPCH1.AE7 (CLKOUT_PCIE_P3); also elsewhere on the board
PCH_x4_5_Refclk-: UPCH1.AE6 (CLKOUT_PCIE_N3); also elsewhere on the board
PCH_x4_6_CLKREQ#: UPCH1.AR32 (GPP_B7/SRCCLKREQ2#); also elsewhere on the board
PCH_x4_6_PCIe_Rx0+: UPCH1.R44 (PCIE21_RXP); also elsewhere on the board
PCH_x4_6_PCIe_Rx0-: UPCH1.T43 (PCIE21_RXN); also elsewhere on the board
PCH_x4_6_PCIe_Rx1+: UPCH1.U41 (PCIE22_RXP); also elsewhere on the board
PCH_x4_6_PCIe_Rx1-: UPCH1.U40 (PCIE22_RXN); also elsewhere on the board
PCH_x4_6_PCIe_Rx2+: UPCH1.W44 (PCIE23_RXP); also elsewhere on the board
PCH_x4_6_PCIe_Rx2-: UPCH1.W43 (PCIE23_RXN); also elsewhere on the board
PCH_x4_6_PCIe_Rx3+: UPCH1.Y41 (PCIE24_RXP); also elsewhere on the board
PCH_x4_6_PCIe_Rx3-: UPCH1.Y40 (PCIE24_RXN); also elsewhere on the board
PCH_x4_6_PCIe_Tx0+: UPCH1.F46 (PCIE21_TXP); also elsewhere on the board
PCH_x4_6_PCIe_Tx0-: UPCH1.G47 (PCIE21_TXN); also elsewhere on the board
PCH_x4_6_PCIe_Tx1+: UPCH1.H48 (PCIE22_TXP); also elsewhere on the board
PCH_x4_6_PCIe_Tx1-: UPCH1.H47 (PCIE22_TXN); also elsewhere on the board
PCH_x4_6_PCIe_Tx2+: UPCH1.G48 (PCIE23_TXP); also elsewhere on the board
PCH_x4_6_PCIe_Tx2-: UPCH1.G49 (PCIE23_TXN); also elsewhere on the board
PCH_x4_6_PCIe_Tx3+: UPCH1.G45 (PCIE24_TXP); also elsewhere on the board
PCH_x4_6_PCIe_Tx3-: UPCH1.G46 (PCIE24_TXN); also elsewhere on the board
PCH_x4_6_Refclk+: UPCH1.AE15 (CLKOUT_PCIE_P2); also elsewhere on the board
PCH_x4_6_Refclk-: UPCH1.AE14 (CLKOUT_PCIE_N2); also elsewhere on the board
PCIe_CPU_CLKREQ#: UPCH1.BF31 (GPP_B5/SRCCLKREQ0#); also elsewhere on the board
PCIe_CPU_Refclk+: UPCH1.AJ7 (CLKOUT_PCIE_P0); also elsewhere on the board
PCIe_CPU_Refclk-: UPCH1.AJ6 (CLKOUT_PCIE_N0); also elsewhere on the board
PECI_PCH: R41.2, UPCH1.AF2 (PECI); also elsewhere on the board
PLTRST_CPU#: UPCH1.AG5 (PLTRST_CPU#); also elsewhere on the board
PM_DOWN_PCH: UPCH1.AE2 (PM_DOWN); also elsewhere on the board
PM_SYNC_PCH: UPCH1.AF3 (PM_SYNC); also elsewhere on the board
SSD0_CLKREQ#: UPCH1.BE31 (GPP_B6/SRCCLKREQ1#); also elsewhere on the board
SSD0_PCIe_Rx1+: UPCH1.F39 (PCIE11_RXP/SATA0A_RXP); also elsewhere on the board
SSD0_PCIe_Rx1-: UPCH1.G38 (PCIE11_RXN/SATA0A_RXN); also elsewhere on the board
SSD0_PCIe_Rx2+: UPCH1.J37 (PCIE10_RXP); also elsewhere on the board
SSD0_PCIe_Rx2-: UPCH1.K37 (PCIE10_RXN); also elsewhere on the board
SSD0_PCIe_Rx3+: UPCH1.F36 (PCIE9_RXP); also elsewhere on the board
SSD0_PCIe_Rx3-: UPCH1.G36 (PCIE9_RXN); also elsewhere on the board
SSD0_PCIe_Tx1+: UPCH1.C36 (PCIE11_TXP/SATA0A_TXP); also elsewhere on the board
SSD0_PCIe_Tx1-: UPCH1.B36 (PCIE11_TXN/SATA0A_TXN); also elsewhere on the board
SSD0_PCIe_Tx2+: UPCH1.B35 (PCIE10_TXP); also elsewhere on the board
SSD0_PCIe_Tx2-: UPCH1.C35 (PCIE10_TXN); also elsewhere on the board
SSD0_PCIe_Tx3+: UPCH1.D34 (PCIE9_TXP); also elsewhere on the board
SSD0_PCIe_Tx3-: UPCH1.C34 (PCIE9_TXN); also elsewhere on the board
SSD0_Refclk+: UPCH1.AH10 (CLKOUT_PCIE_P1); also elsewhere on the board
SSD0_Refclk-: UPCH1.AH9 (CLKOUT_PCIE_N1); also elsewhere on the board
SSD0_SATA/PCIe_Rx0+: UPCH1.J41 (PCIE12_RXP/SATA1A_RXP); also elsewhere on the board
SSD0_SATA/PCIe_Rx0-: UPCH1.H42 (PCIE12_RXN/SATA1A_RXN); also elsewhere on the board
SSD0_SATA/PCIe_Tx0+: UPCH1.E37 (PCIE12_TXP/SATA1A_TXP); also elsewhere on the board
SSD0_SATA/PCIe_Tx0-: UPCH1.D38 (PCIE12_TXN/SATA1A_TXN); also elsewhere on the board
S_DMI_CRx_PTx_0+: UPCH1.B33 (DMI0_TXP); also elsewhere on the board
S_DMI_CRx_PTx_0-: UPCH1.C33 (DMI0_TXN); also elsewhere on the board
S_DMI_CRx_PTx_1+: UPCH1.B32 (DMI1_TXP); also elsewhere on the board
S_DMI_CRx_PTx_1-: UPCH1.C32 (DMI1_TXN); also elsewhere on the board
S_DMI_CRx_PTx_2+: UPCH1.B31 (DMI2_TXP); also elsewhere on the board
S_DMI_CRx_PTx_2-: UPCH1.C31 (DMI2_TXN); also elsewhere on the board
S_DMI_CRx_PTx_3+: UPCH1.B29 (DMI3_TXP); also elsewhere on the board
S_DMI_CRx_PTx_3-: UPCH1.C29 (DMI3_TXN); also elsewhere on the board
S_DMI_CRx_PTx_4+: UPCH1.D29 (DMI4_TXP); also elsewhere on the board
S_DMI_CRx_PTx_4-: UPCH1.E28 (DMI4_TXN); also elsewhere on the board
S_DMI_CRx_PTx_5+: UPCH1.B27 (DMI5_TXP); also elsewhere on the board
S_DMI_CRx_PTx_5-: UPCH1.C27 (DMI5_TXN); also elsewhere on the board
S_DMI_CRx_PTx_6+: UPCH1.C26 (DMI6_TXP); also elsewhere on the board
S_DMI_CRx_PTx_6-: UPCH1.B26 (DMI6_TXN); also elsewhere on the board
S_DMI_CRx_PTx_7+: UPCH1.A25 (DMI7_TXP); also elsewhere on the board
S_DMI_CRx_PTx_7-: UPCH1.B25 (DMI7_TXN); also elsewhere on the board
S_DMI_CTx_PRx_0+: UPCH1.J35 (DMI0_RXP); also elsewhere on the board
S_DMI_CTx_PRx_0-: UPCH1.K34 (DMI0_RXN); also elsewhere on the board
S_DMI_CTx_PRx_1+: UPCH1.F34 (DMI1_RXP); also elsewhere on the board
S_DMI_CTx_PRx_1-: UPCH1.G33 (DMI1_RXN); also elsewhere on the board
S_DMI_CTx_PRx_2+: UPCH1.J32 (DMI2_RXP); also elsewhere on the board
S_DMI_CTx_PRx_2-: UPCH1.K32 (DMI2_RXN); also elsewhere on the board
S_DMI_CTx_PRx_3+: UPCH1.F30 (DMI3_RXP); also elsewhere on the board
S_DMI_CTx_PRx_3-: UPCH1.G30 (DMI3_RXN); also elsewhere on the board
S_DMI_CTx_PRx_4+: UPCH1.K29 (DMI4_RXP); also elsewhere on the board
S_DMI_CTx_PRx_4-: UPCH1.M29 (DMI4_RXN); also elsewhere on the board
S_DMI_CTx_PRx_5+: UPCH1.L26 (DMI5_RXP); also elsewhere on the board
S_DMI_CTx_PRx_5-: UPCH1.M26 (DMI5_RXN); also elsewhere on the board
S_DMI_CTx_PRx_6+: UPCH1.F26 (DMI6_RXP); also elsewhere on the board
S_DMI_CTx_PRx_6-: UPCH1.G26 (DMI6_RXN); also elsewhere on the board
S_DMI_CTx_PRx_7+: UPCH1.P24 (DMI7_RXP); also elsewhere on the board
S_DMI_CTx_PRx_7-: UPCH1.R24 (DMI7_RXN); also elsewhere on the board
THERMTRIP#: R38.2; also elsewhere on the board
eDP_BLEN: UPCH1.AV46 (GPP_F20/EDP_BKLTEN)
eDP_PWM: UPCH1.AU48 (GPP_F21/EDP_BKLTCTL); also elsewhere on the board
eDP_VDDEN: UPCH1.AV44 (GPP_F19/EDP_VDDEN)

Notes on the sheet:
subtract 5 for PCIe lane number (first 6 lanes are the USB3.1G2 ports + index starts at 0 vs 1)
Keep CLKREQ# and Refclk+/- paired!
Z390 pls (or Q370 but idk how to handle AMT)
PCIe controller 1 (L1-4): ? PCIe controller 2 (L5-8): ? PCIe controller 3 (L9-12): NVMe 0 with lane reversal for SATA on first lane x2 no SATA on H310, x4 with SATA on all other chipsets PCIe controller 4 (L13-16): ? PCIe controller 5 (L17-20): ? PCIe controller 6 (L21-24): ?
PCIe controller 4 (L13-16): Z390/Q370/H370/C246/CM246: 4x SATA + PCIe x4 QM370/HM370: 2x SATA L13/14 + PCIe x4 B360/H310: 4x SATA (GbE supported) C242: 4x SATA -Used for PCIe x4 or 4x SATA adapter
PCIe controller 5 (L17-20): Z390/Q370/QM370/HM370: 2x SATA L17/18 + PCIe x4 H370: 2x SATA L17/18 + PCIe x2 L19/20 B360/C242: 2x SATA L17/18 C246/CM246: 4x SATA + PCIe x4 H310: nothing -Used for PCIe x4 or 4x SATA adapter
PCIe controller 3 (L9-12): H310: PCIe x2 L11/12 All other chipsets: 2x SATA L11/12 + PCIe x4 -Used for NVMe 0 with lane reversal for SATA on first lane
PCIe controller 6 (L21-24): H310: nothing All other chipsets: PCIe x4 -Used for PCIe x4
PCIe controller 1 (L1-4): Z390/Q370/C246/CM246: 4x USB3 + PCIe x4 H370: 2x USB3 L1/2 + PCIe x2 L3/4 C242: PCIe x2 L1/2 HM370: 2x USB3 L1/2 QM370: 4x USB3 B360/H310: nothing -Used for PCIe x4 or 4x USB3 adapter
PCIe controller 2 (L5-8): HM370/C242: nothing All other chipsets: PCIe x4 -Used for: L5: GbE i219 L6: 2.5Gb? L7: A/E-key? L8: A/E-key L2/miniPCIe?

Schematic: DDR4_slots.kicad_sch, 2x DDR4 SODIMM slots

Parts:
JSODIMM1, JSODIMM2: DDR4-sodimm; DDR4-sodimm-std

Connections:
DDR4_CH0_A0: JSODIMM1.144 (A0); also elsewhere on the board
DDR4_CH0_A1: JSODIMM1.133 (A1); also elsewhere on the board
DDR4_CH0_A2: JSODIMM1.132 (A2); also elsewhere on the board
DDR4_CH0_A3: JSODIMM1.131 (A3); also elsewhere on the board
DDR4_CH0_A4: JSODIMM1.128 (A4); also elsewhere on the board
DDR4_CH0_A5: JSODIMM1.126 (A5); also elsewhere on the board
DDR4_CH0_A6: JSODIMM1.127 (A6); also elsewhere on the board
DDR4_CH0_A7: JSODIMM1.122 (A7); also elsewhere on the board
DDR4_CH0_A8: JSODIMM1.125 (A8); also elsewhere on the board
DDR4_CH0_A9: JSODIMM1.121 (A9); also elsewhere on the board
DDR4_CH0_A10: JSODIMM1.146 (A10/AP); also elsewhere on the board
DDR4_CH0_A11: JSODIMM1.120 (A11); also elsewhere on the board
DDR4_CH0_A12: JSODIMM1.119 (A12/BC#); also elsewhere on the board
DDR4_CH0_A13: JSODIMM1.158 (A13); also elsewhere on the board
DDR4_CH0_A14_WE#: JSODIMM1.151 (A14/WE#); also elsewhere on the board
DDR4_CH0_A15_CAS#: JSODIMM1.156 (A15/CAS#); also elsewhere on the board
DDR4_CH0_A16_RAS#: JSODIMM1.152 (A16/RAS#); also elsewhere on the board
DDR4_CH0_ACT#: JSODIMM1.114 (ACT#); also elsewhere on the board
DDR4_CH0_Alert#: JSODIMM1.116 (ALERT#); also elsewhere on the board
DDR4_CH0_BA0: JSODIMM1.150 (BA0); also elsewhere on the board
DDR4_CH0_BA1: JSODIMM1.145 (BA1); also elsewhere on the board
DDR4_CH0_BG0: JSODIMM1.115 (BG0); also elsewhere on the board
DDR4_CH0_BG1: JSODIMM1.113 (BG1); also elsewhere on the board
DDR4_CH0_CKE0: JSODIMM1.109 (CKE0); also elsewhere on the board
DDR4_CH0_CKE1: JSODIMM1.110 (CKE1); also elsewhere on the board
DDR4_CH0_CLK0+: JSODIMM1.137 (CK0+); also elsewhere on the board
DDR4_CH0_CLK0-: JSODIMM1.139 (CK0-); also elsewhere on the board
DDR4_CH0_CLK1+: JSODIMM1.138 (CK1+); also elsewhere on the board
DDR4_CH0_CLK1-: JSODIMM1.140 (CK1-); also elsewhere on the board
DDR4_CH0_CS0#: JSODIMM1.149 (CS0#); also elsewhere on the board
DDR4_CH0_CS1#: JSODIMM1.157 (CS1#); also elsewhere on the board
DDR4_CH0_DQ0: JSODIMM1.8 (DQ0); also elsewhere on the board
DDR4_CH0_DQ1: JSODIMM1.7 (DQ1); also elsewhere on the board
DDR4_CH0_DQ2: JSODIMM1.20 (DQ2); also elsewhere on the board
DDR4_CH0_DQ3: JSODIMM1.21 (DQ3); also elsewhere on the board
DDR4_CH0_DQ4: JSODIMM1.4 (DQ4); also elsewhere on the board
DDR4_CH0_DQ5: JSODIMM1.3 (DQ5); also elsewhere on the board
DDR4_CH0_DQ6: JSODIMM1.16 (DQ6); also elsewhere on the board
DDR4_CH0_DQ7: JSODIMM1.17 (DQ7); also elsewhere on the board
DDR4_CH0_DQ8: JSODIMM1.28 (DQ8); also elsewhere on the board
DDR4_CH0_DQ9: JSODIMM1.29 (DQ9); also elsewhere on the board
DDR4_CH0_DQ10: JSODIMM1.41 (DQ10); also elsewhere on the board
DDR4_CH0_DQ11: JSODIMM1.42 (DQ11); also elsewhere on the board
DDR4_CH0_DQ12: JSODIMM1.24 (DQ12); also elsewhere on the board
DDR4_CH0_DQ13: JSODIMM1.25 (DQ13); also elsewhere on the board
DDR4_CH0_DQ14: JSODIMM1.38 (DQ14); also elsewhere on the board
DDR4_CH0_DQ15: JSODIMM1.37 (DQ15); also elsewhere on the board
DDR4_CH0_DQ16: JSODIMM1.50 (DQ16); also elsewhere on the board
DDR4_CH0_DQ17: JSODIMM1.49 (DQ17); also elsewhere on the board
DDR4_CH0_DQ18: JSODIMM1.62 (DQ18); also elsewhere on the board
DDR4_CH0_DQ19: JSODIMM1.63 (DQ19); also elsewhere on the board
DDR4_CH0_DQ20: JSODIMM1.46 (DQ20); also elsewhere on the board
DDR4_CH0_DQ21: JSODIMM1.45 (DQ21); also elsewhere on the board
DDR4_CH0_DQ22: JSODIMM1.58 (DQ22); also elsewhere on the board
DDR4_CH0_DQ23: JSODIMM1.59 (DQ23); also elsewhere on the board
DDR4_CH0_DQ24: JSODIMM1.70 (DQ24); also elsewhere on the board
DDR4_CH0_DQ25: JSODIMM1.71 (DQ25); also elsewhere on the board
DDR4_CH0_DQ26: JSODIMM1.83 (DQ26); also elsewhere on the board
DDR4_CH0_DQ27: JSODIMM1.84 (DQ27); also elsewhere on the board
DDR4_CH0_DQ28: JSODIMM1.66 (DQ28); also elsewhere on the board
DDR4_CH0_DQ29: JSODIMM1.67 (DQ29); also elsewhere on the board
DDR4_CH0_DQ30: JSODIMM1.79 (DQ30); also elsewhere on the board
DDR4_CH0_DQ31: JSODIMM1.80 (DQ31); also elsewhere on the board
DDR4_CH0_DQ32: JSODIMM1.174 (DQ32); also elsewhere on the board
DDR4_CH0_DQ33: JSODIMM1.173 (DQ33); also elsewhere on the board
DDR4_CH0_DQ34: JSODIMM1.187 (DQ34); also elsewhere on the board
DDR4_CH0_DQ35: JSODIMM1.186 (DQ35); also elsewhere on the board
DDR4_CH0_DQ36: JSODIMM1.170 (DQ36); also elsewhere on the board
DDR4_CH0_DQ37: JSODIMM1.169 (DQ37); also elsewhere on the board
DDR4_CH0_DQ38: JSODIMM1.183 (DQ38); also elsewhere on the board
DDR4_CH0_DQ39: JSODIMM1.182 (DQ39); also elsewhere on the board
DDR4_CH0_DQ40: JSODIMM1.195 (DQ40); also elsewhere on the board
DDR4_CH0_DQ41: JSODIMM1.194 (DQ41); also elsewhere on the board
DDR4_CH0_DQ42: JSODIMM1.207 (DQ42); also elsewhere on the board
DDR4_CH0_DQ43: JSODIMM1.208 (DQ43); also elsewhere on the board
DDR4_CH0_DQ44: JSODIMM1.191 (DQ44); also elsewhere on the board
DDR4_CH0_DQ45: JSODIMM1.190 (DQ45); also elsewhere on the board
DDR4_CH0_DQ46: JSODIMM1.203 (DQ46); also elsewhere on the board
DDR4_CH0_DQ47: JSODIMM1.204 (DQ47); also elsewhere on the board
DDR4_CH0_DQ48: JSODIMM1.216 (DQ48); also elsewhere on the board
DDR4_CH0_DQ49: JSODIMM1.215 (DQ49); also elsewhere on the board
DDR4_CH0_DQ50: JSODIMM1.228 (DQ50); also elsewhere on the board
DDR4_CH0_DQ51: JSODIMM1.229 (DQ51); also elsewhere on the board
DDR4_CH0_DQ52: JSODIMM1.211 (DQ52); also elsewhere on the board
DDR4_CH0_DQ53: JSODIMM1.212 (DQ53); also elsewhere on the board
DDR4_CH0_DQ54: JSODIMM1.224 (DQ54); also elsewhere on the board
DDR4_CH0_DQ55: JSODIMM1.225 (DQ55); also elsewhere on the board
DDR4_CH0_DQ56: JSODIMM1.237 (DQ56); also elsewhere on the board
DDR4_CH0_DQ57: JSODIMM1.236 (DQ57); also elsewhere on the board
DDR4_CH0_DQ58: JSODIMM1.249 (DQ58); also elsewhere on the board
DDR4_CH0_DQ59: JSODIMM1.250 (DQ59); also elsewhere on the board
DDR4_CH0_DQ60: JSODIMM1.232 (DQ60); also elsewhere on the board
DDR4_CH0_DQ61: JSODIMM1.233 (DQ61); also elsewhere on the board
DDR4_CH0_DQ62: JSODIMM1.245 (DQ62); also elsewhere on the board
DDR4_CH0_DQ63: JSODIMM1.246 (DQ63); also elsewhere on the board
DDR4_CH0_DQS0+: JSODIMM1.13 (DQS0+); also elsewhere on the board
DDR4_CH0_DQS0-: JSODIMM1.11 (DQS0-); also elsewhere on the board
DDR4_CH0_DQS1+: JSODIMM1.34 (DQS1+); also elsewhere on the board
DDR4_CH0_DQS1-: JSODIMM1.32 (DQS1-); also elsewhere on the board
DDR4_CH0_DQS2+: JSODIMM1.55 (DQS2+); also elsewhere on the board
DDR4_CH0_DQS2-: JSODIMM1.53 (DQS2-); also elsewhere on the board
DDR4_CH0_DQS3+: JSODIMM1.76 (DQS3+); also elsewhere on the board
DDR4_CH0_DQS3-: JSODIMM1.74 (DQS3-); also elsewhere on the board
DDR4_CH0_DQS4+: JSODIMM1.179 (DQS4+); also elsewhere on the board
DDR4_CH0_DQS4-: JSODIMM1.177 (DQS4-); also elsewhere on the board
DDR4_CH0_DQS5+: JSODIMM1.200 (DQS5+); also elsewhere on the board
DDR4_CH0_DQS5-: JSODIMM1.198 (DQS5-); also elsewhere on the board
DDR4_CH0_DQS6+: JSODIMM1.221 (DQS6+); also elsewhere on the board
DDR4_CH0_DQS6-: JSODIMM1.219 (DQS6-); also elsewhere on the board
DDR4_CH0_DQS7+: JSODIMM1.242 (DQS7+); also elsewhere on the board
DDR4_CH0_DQS7-: JSODIMM1.240 (DQS7-); also elsewhere on the board
DDR4_CH0_DQS8+: JSODIMM1.97 (DQS8+); also elsewhere on the board
DDR4_CH0_DQS8-: JSODIMM1.95 (DQS8-); also elsewhere on the board
DDR4_CH0_ECC0: JSODIMM1.92 (CB0); also elsewhere on the board
DDR4_CH0_ECC1: JSODIMM1.91 (CB1); also elsewhere on the board
DDR4_CH0_ECC2: JSODIMM1.101 (CB2); also elsewhere on the board
DDR4_CH0_ECC3: JSODIMM1.105 (CB3); also elsewhere on the board
DDR4_CH0_ECC4: JSODIMM1.88 (CB4); also elsewhere on the board
DDR4_CH0_ECC5: JSODIMM1.87 (CB5); also elsewhere on the board
DDR4_CH0_ECC6: JSODIMM1.100 (CB6); also elsewhere on the board
DDR4_CH0_ECC7: JSODIMM1.104 (CB7); also elsewhere on the board
DDR4_CH0_ODT0: JSODIMM1.155 (ODT0); also elsewhere on the board
DDR4_CH0_ODT1: JSODIMM1.161 (ODT1); also elsewhere on the board
DDR4_CH0_Parity: JSODIMM1.143 (PARITY); also elsewhere on the board
DDR4_CH1_A0: JSODIMM2.144 (A0); also elsewhere on the board
DDR4_CH1_A1: JSODIMM2.133 (A1); also elsewhere on the board
DDR4_CH1_A2: JSODIMM2.132 (A2); also elsewhere on the board
DDR4_CH1_A3: JSODIMM2.131 (A3); also elsewhere on the board
DDR4_CH1_A4: JSODIMM2.128 (A4); also elsewhere on the board
DDR4_CH1_A5: JSODIMM2.126 (A5); also elsewhere on the board
DDR4_CH1_A6: JSODIMM2.127 (A6); also elsewhere on the board
DDR4_CH1_A7: JSODIMM2.122 (A7); also elsewhere on the board
DDR4_CH1_A8: JSODIMM2.125 (A8); also elsewhere on the board
DDR4_CH1_A9: JSODIMM2.121 (A9); also elsewhere on the board
DDR4_CH1_A10: JSODIMM2.146 (A10/AP); also elsewhere on the board
DDR4_CH1_A11: JSODIMM2.120 (A11); also elsewhere on the board
DDR4_CH1_A12: JSODIMM2.119 (A12/BC#); also elsewhere on the board
DDR4_CH1_A13: JSODIMM2.158 (A13); also elsewhere on the board
DDR4_CH1_A14_WE#: JSODIMM2.151 (A14/WE#); also elsewhere on the board
DDR4_CH1_A15_CAS#: JSODIMM2.156 (A15/CAS#); also elsewhere on the board
DDR4_CH1_A16_RAS#: JSODIMM2.152 (A16/RAS#); also elsewhere on the board
DDR4_CH1_ACT#: JSODIMM2.114 (ACT#); also elsewhere on the board
DDR4_CH1_Alert#: JSODIMM2.116 (ALERT#); also elsewhere on the board
DDR4_CH1_BA0: JSODIMM2.150 (BA0); also elsewhere on the board
DDR4_CH1_BA1: JSODIMM2.145 (BA1); also elsewhere on the board
DDR4_CH1_BG0: JSODIMM2.115 (BG0); also elsewhere on the board
DDR4_CH1_BG1: JSODIMM2.113 (BG1); also elsewhere on the board
DDR4_CH1_CKE0: JSODIMM2.109 (CKE0); also elsewhere on the board
DDR4_CH1_CKE1: JSODIMM2.110 (CKE1); also elsewhere on the board
DDR4_CH1_CLK0+: JSODIMM2.137 (CK0+); also elsewhere on the board
DDR4_CH1_CLK0-: JSODIMM2.139 (CK0-); also elsewhere on the board
DDR4_CH1_CLK1+: JSODIMM2.138 (CK1+); also elsewhere on the board
DDR4_CH1_CLK1-: JSODIMM2.140 (CK1-); also elsewhere on the board
DDR4_CH1_CS0#: JSODIMM2.149 (CS0#); also elsewhere on the board
DDR4_CH1_CS1#: JSODIMM2.157 (CS1#); also elsewhere on the board
DDR4_CH1_DQ0: JSODIMM2.8 (DQ0); also elsewhere on the board
DDR4_CH1_DQ1: JSODIMM2.7 (DQ1); also elsewhere on the board
DDR4_CH1_DQ2: JSODIMM2.20 (DQ2); also elsewhere on the board
DDR4_CH1_DQ3: JSODIMM2.21 (DQ3); also elsewhere on the board
DDR4_CH1_DQ4: JSODIMM2.4 (DQ4); also elsewhere on the board
DDR4_CH1_DQ5: JSODIMM2.3 (DQ5); also elsewhere on the board
DDR4_CH1_DQ6: JSODIMM2.16 (DQ6); also elsewhere on the board
DDR4_CH1_DQ7: JSODIMM2.17 (DQ7); also elsewhere on the board
DDR4_CH1_DQ8: JSODIMM2.28 (DQ8); also elsewhere on the board
DDR4_CH1_DQ9: JSODIMM2.29 (DQ9); also elsewhere on the board
DDR4_CH1_DQ10: JSODIMM2.41 (DQ10); also elsewhere on the board
DDR4_CH1_DQ11: JSODIMM2.42 (DQ11); also elsewhere on the board
DDR4_CH1_DQ12: JSODIMM2.24 (DQ12); also elsewhere on the board
DDR4_CH1_DQ13: JSODIMM2.25 (DQ13); also elsewhere on the board
DDR4_CH1_DQ14: JSODIMM2.38 (DQ14); also elsewhere on the board
DDR4_CH1_DQ15: JSODIMM2.37 (DQ15); also elsewhere on the board
DDR4_CH1_DQ16: JSODIMM2.50 (DQ16); also elsewhere on the board
DDR4_CH1_DQ17: JSODIMM2.49 (DQ17); also elsewhere on the board
DDR4_CH1_DQ18: JSODIMM2.62 (DQ18); also elsewhere on the board
DDR4_CH1_DQ19: JSODIMM2.63 (DQ19); also elsewhere on the board
DDR4_CH1_DQ20: JSODIMM2.46 (DQ20); also elsewhere on the board
DDR4_CH1_DQ21: JSODIMM2.45 (DQ21); also elsewhere on the board
DDR4_CH1_DQ22: JSODIMM2.58 (DQ22); also elsewhere on the board
DDR4_CH1_DQ23: JSODIMM2.59 (DQ23); also elsewhere on the board
DDR4_CH1_DQ24: JSODIMM2.70 (DQ24); also elsewhere on the board
DDR4_CH1_DQ25: JSODIMM2.71 (DQ25); also elsewhere on the board
DDR4_CH1_DQ26: JSODIMM2.83 (DQ26); also elsewhere on the board
DDR4_CH1_DQ27: JSODIMM2.84 (DQ27); also elsewhere on the board
DDR4_CH1_DQ28: JSODIMM2.66 (DQ28); also elsewhere on the board
DDR4_CH1_DQ29: JSODIMM2.67 (DQ29); also elsewhere on the board
DDR4_CH1_DQ30: JSODIMM2.79 (DQ30); also elsewhere on the board
DDR4_CH1_DQ31: JSODIMM2.80 (DQ31); also elsewhere on the board
DDR4_CH1_DQ32: JSODIMM2.174 (DQ32); also elsewhere on the board
DDR4_CH1_DQ33: JSODIMM2.173 (DQ33); also elsewhere on the board
DDR4_CH1_DQ34: JSODIMM2.187 (DQ34); also elsewhere on the board
DDR4_CH1_DQ35: JSODIMM2.186 (DQ35); also elsewhere on the board
DDR4_CH1_DQ36: JSODIMM2.170 (DQ36); also elsewhere on the board
DDR4_CH1_DQ37: JSODIMM2.169 (DQ37); also elsewhere on the board
DDR4_CH1_DQ38: JSODIMM2.183 (DQ38); also elsewhere on the board
DDR4_CH1_DQ39: JSODIMM2.182 (DQ39); also elsewhere on the board
DDR4_CH1_DQ40: JSODIMM2.195 (DQ40); also elsewhere on the board
DDR4_CH1_DQ41: JSODIMM2.194 (DQ41); also elsewhere on the board
DDR4_CH1_DQ42: JSODIMM2.207 (DQ42); also elsewhere on the board
DDR4_CH1_DQ43: JSODIMM2.208 (DQ43); also elsewhere on the board
DDR4_CH1_DQ44: JSODIMM2.191 (DQ44); also elsewhere on the board
DDR4_CH1_DQ45: JSODIMM2.190 (DQ45); also elsewhere on the board
DDR4_CH1_DQ46: JSODIMM2.203 (DQ46); also elsewhere on the board
DDR4_CH1_DQ47: JSODIMM2.204 (DQ47); also elsewhere on the board
DDR4_CH1_DQ48: JSODIMM2.216 (DQ48); also elsewhere on the board
DDR4_CH1_DQ49: JSODIMM2.215 (DQ49); also elsewhere on the board
DDR4_CH1_DQ50: JSODIMM2.228 (DQ50); also elsewhere on the board
DDR4_CH1_DQ51: JSODIMM2.229 (DQ51); also elsewhere on the board
DDR4_CH1_DQ52: JSODIMM2.211 (DQ52); also elsewhere on the board
DDR4_CH1_DQ53: JSODIMM2.212 (DQ53); also elsewhere on the board
DDR4_CH1_DQ54: JSODIMM2.224 (DQ54); also elsewhere on the board
DDR4_CH1_DQ55: JSODIMM2.225 (DQ55); also elsewhere on the board
DDR4_CH1_DQ56: JSODIMM2.237 (DQ56); also elsewhere on the board
DDR4_CH1_DQ57: JSODIMM2.236 (DQ57); also elsewhere on the board
DDR4_CH1_DQ58: JSODIMM2.249 (DQ58); also elsewhere on the board
DDR4_CH1_DQ59: JSODIMM2.250 (DQ59); also elsewhere on the board
DDR4_CH1_DQ60: JSODIMM2.232 (DQ60); also elsewhere on the board
DDR4_CH1_DQ61: JSODIMM2.233 (DQ61); also elsewhere on the board
DDR4_CH1_DQ62: JSODIMM2.245 (DQ62); also elsewhere on the board
DDR4_CH1_DQ63: JSODIMM2.246 (DQ63); also elsewhere on the board
DDR4_CH1_DQS0+: JSODIMM2.13 (DQS0+); also elsewhere on the board
DDR4_CH1_DQS0-: JSODIMM2.11 (DQS0-); also elsewhere on the board
DDR4_CH1_DQS1+: JSODIMM2.34 (DQS1+); also elsewhere on the board
DDR4_CH1_DQS1-: JSODIMM2.32 (DQS1-); also elsewhere on the board
DDR4_CH1_DQS2+: JSODIMM2.55 (DQS2+); also elsewhere on the board
DDR4_CH1_DQS2-: JSODIMM2.53 (DQS2-); also elsewhere on the board
DDR4_CH1_DQS3+: JSODIMM2.76 (DQS3+); also elsewhere on the board
DDR4_CH1_DQS3-: JSODIMM2.74 (DQS3-); also elsewhere on the board
DDR4_CH1_DQS4+: JSODIMM2.179 (DQS4+); also elsewhere on the board
DDR4_CH1_DQS4-: JSODIMM2.177 (DQS4-); also elsewhere on the board
DDR4_CH1_DQS5+: JSODIMM2.200 (DQS5+); also elsewhere on the board
DDR4_CH1_DQS5-: JSODIMM2.198 (DQS5-); also elsewhere on the board
DDR4_CH1_DQS6+: JSODIMM2.221 (DQS6+); also elsewhere on the board
DDR4_CH1_DQS6-: JSODIMM2.219 (DQS6-); also elsewhere on the board
DDR4_CH1_DQS7+: JSODIMM2.242 (DQS7+); also elsewhere on the board
DDR4_CH1_DQS7-: JSODIMM2.240 (DQS7-); also elsewhere on the board
DDR4_CH1_DQS8+: JSODIMM2.97 (DQS8+); also elsewhere on the board
DDR4_CH1_DQS8-: JSODIMM2.95 (DQS8-); also elsewhere on the board
DDR4_CH1_ECC0: JSODIMM2.92 (CB0); also elsewhere on the board
DDR4_CH1_ECC1: JSODIMM2.91 (CB1); also elsewhere on the board
DDR4_CH1_ECC2: JSODIMM2.101 (CB2); also elsewhere on the board
DDR4_CH1_ECC3: JSODIMM2.105 (CB3); also elsewhere on the board
DDR4_CH1_ECC4: JSODIMM2.88 (CB4); also elsewhere on the board
DDR4_CH1_ECC5: JSODIMM2.87 (CB5); also elsewhere on the board
DDR4_CH1_ECC6: JSODIMM2.100 (CB6); also elsewhere on the board
DDR4_CH1_ECC7: JSODIMM2.104 (CB7); also elsewhere on the board
DDR4_CH1_ODT0: JSODIMM2.155 (ODT0); also elsewhere on the board
DDR4_CH1_ODT1: JSODIMM2.161 (ODT1); also elsewhere on the board
DDR4_CH1_Parity: JSODIMM2.143 (PARITY); also elsewhere on the board
GND: JSODIMM1.1 (VSS), JSODIMM1.2 (VSS), JSODIMM1.5 (VSS), JSODIMM1.6 (VSS), JSODIMM1.9 (VSS), JSODIMM1.10 (VSS), JSODIMM1.14 (VSS), JSODIMM1.15 (VSS), JSODIMM1.18 (VSS), JSODIMM1.19 (VSS), JSODIMM1.22 (VSS), JSODIMM1.23 (VSS), JSODIMM1.26 (VSS), JSODIMM1.27 (VSS), JSODIMM1.30 (VSS), JSODIMM1.31 (VSS), JSODIMM1.35 (VSS), JSODIMM1.36 (VSS), JSODIMM1.39 (VSS), JSODIMM1.40 (VSS), JSODIMM1.43 (VSS), JSODIMM1.44 (VSS), JSODIMM1.47 (VSS), JSODIMM1.48 (VSS), JSODIMM1.51 (VSS), JSODIMM1.52 (VSS), JSODIMM1.56 (VSS), JSODIMM1.57 (VSS), JSODIMM1.60 (VSS), JSODIMM1.61 (VSS), JSODIMM1.64 (VSS), JSODIMM1.65 (VSS), JSODIMM1.68 (VSS), JSODIMM1.69 (VSS), JSODIMM1.72 (VSS), JSODIMM1.73 (VSS), JSODIMM1.77 (VSS), JSODIMM1.78 (VSS), JSODIMM1.81 (VSS), JSODIMM1.82 (VSS), JSODIMM1.85 (VSS), JSODIMM1.86 (VSS), JSODIMM1.89 (VSS), JSODIMM1.90 (VSS), JSODIMM1.93 (VSS), JSODIMM1.94 (VSS), JSODIMM1.98 (VSS), JSODIMM1.99 (VSS), JSODIMM1.102 (VSS), JSODIMM1.103 (VSS), JSODIMM1.106 (VSS), JSODIMM1.107 (VSS), JSODIMM1.167 (VSS), JSODIMM1.168 (VSS), JSODIMM1.171 (VSS), JSODIMM1.172 (VSS), JSODIMM1.175 (VSS), JSODIMM1.176 (VSS), JSODIMM1.180 (VSS), JSODIMM1.181 (VSS), JSODIMM1.184 (VSS), JSODIMM1.185 (VSS), JSODIMM1.188 (VSS), JSODIMM1.189 (VSS), JSODIMM1.192 (VSS), JSODIMM1.193 (VSS), JSODIMM1.196 (VSS), JSODIMM1.197 (VSS), JSODIMM1.201 (VSS), JSODIMM1.202 (VSS), JSODIMM1.205 (VSS), JSODIMM1.206 (VSS), JSODIMM1.209 (VSS), JSODIMM1.210 (VSS), JSODIMM1.213 (VSS), JSODIMM1.214 (VSS), JSODIMM1.217 (VSS), JSODIMM1.218 (VSS), JSODIMM1.222 (VSS), JSODIMM1.223 (VSS)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; also elsewhere on the board
